# IAR project ucos_iii_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_1769 (ARM)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\CMSIS\CMSIS\include; ..\..\..\..\examples\ucos_iii\ucos_iii_blinky\ucos_iii_config; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\..\software\ucos_iii\lpc_ucos_iii\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source; ..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x; ..\..\..\..\examples\ucos_iii\ucos_iii_blinky
  OBJCOPY.OOCOutputFile: ucos_iii_blinky.bin
  ILINK.IlinkOutputFile: ucos_iii_blinky_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../../examples/ucos_iii/startup_code/: iar_ucos_iii_startup_lpc17xx_40xx.s
    ../../../../startup_code/: sysinit.c
    ../../../../examples/ucos_iii/ucos_iii_blinky/: ucos_iii_blinky.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/iar_output/Exe/: board_nxp_lpcxpresso_1769.a
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/iar_output/Exe/: chip_175x_6x_lib.a
  group ucos_iii
    ../../../../../../software/ucos_iii/lpc_ucos_iii/lpc17xx40xx_bsp/: cpu_bsp.c
    ../../../../../../software/ucos_iii/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos_iii_lpc17xx
    ../../../../../../software/ucos_iii/lpc_ucos_iii/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm
    ../../../../../../software/ucos_iii/lpc_ucos_iii/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.s os_cpu_c.c
