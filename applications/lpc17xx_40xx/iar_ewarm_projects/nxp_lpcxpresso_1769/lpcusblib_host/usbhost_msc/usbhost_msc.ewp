# IAR project usbhost_msc.ewp, settings and files
configuration iflash_nxp_lpcxpresso_1769 (ARM)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC175X_6X__; USB_HOST_ONLY
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include; ..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\examples\LPCUSBlib\lpcusblib_MassStorageHost
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x
  OBJCOPY.OOCOutputFile: usbhost_msc.bin
  ILINK.IlinkOutputFile: usbhost_msc$CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\LPC1769_iflash_periphram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/LPCUSBlib/lpcusblib_MassStorageHost/: readme.txt
  group example
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_usb.c rtc.c
    ../../../../startup_code/: iar_startup_lpc175x_6x.s sysinit.c
    ../../../../examples/LPCUSBlib/lpcusblib_MassStorageHost/: MassStorageHost.c
  group example/lpcusblib
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Class/Host/: MassStorageClassHost.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/OHCI/: OHCI.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/iar_output/Exe/: board_nxp_lpcxpresso_1769.a
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/iar_output/Exe/: chip_175x_6x_lib.a
