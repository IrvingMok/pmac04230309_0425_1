# IAR project periph_watchdog.ewp, settings and files
configuration iflash_nxp_lpcxpresso_1769 (ARM)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x
  OBJCOPY.OOCOutputFile: periph_watchdog.bin
  ILINK.IlinkOutputFile: watchdog_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/periph/periph_watchdog/: readme.txt
  group example
    ../../../../startup_code/: iar_startup_lpc175x_6x.s sysinit.c
    ../../../../examples/periph/periph_watchdog/: watchdog.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/iar_output/Exe/: board_nxp_lpcxpresso_1769.a
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/iar_output/Exe/: chip_175x_6x_lib.a
