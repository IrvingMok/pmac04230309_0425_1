# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_1769 (ARM)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\software\lpc_core; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx; ..\..\..\..\..\..\software\lpc_core\lpc_board\board_common; ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\CMSIS\CMSIS\include; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3; ..\..\..\..\..\..\software\CMSIS; ..\..\..\..\examples\freertos\freertos_blinky
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M3
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x; ..\..\..\..\examples\freertos\freertos_blinky
  OBJCOPY.OOCOutputFile: freertos_blinky.bin
  ILINK.IlinkOutputFile: freertos_blinky_$CONFIG_NAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../examples/freertos/freertos_blinky/: readme.txt
  group example
    ../../../../examples/freertos/freertos_blinky/: freertos_blinky.c
    ../../../../startup_code/: iar_startup_lpc175x_6x.s sysinit.c
  group freertos
    ../../../../../../software/freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
  group freertos_17xx
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/iar_output/Exe/: board_nxp_lpcxpresso_1769.a
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/iar_output/Exe/: chip_175x_6x_lib.a
