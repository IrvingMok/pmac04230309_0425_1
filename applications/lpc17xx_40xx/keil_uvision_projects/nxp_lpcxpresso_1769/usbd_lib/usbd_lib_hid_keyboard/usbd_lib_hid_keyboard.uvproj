# Keil uVision project usbd_lib_hid_keyboard.uvproj, settings and files
target iflash_nxp_lpcxpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: hid_keyboard_iflash_nxp_lpcxpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom;..\..\..\..\..\..\software\lpc_core;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769;..\..\..\..\examples\usbd_lib\usbd_lib_hid_keyboard
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_1769;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../startup_code/: sysinit.c keil_startup_lpc175x_6x.s
    ../../../../examples/usbd_lib/usbd_lib_hid_keyboard/: hid_desc.c hid_keyboard.c hid_main.c ms_timer.c readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/keil_output/: board_nxp_lpcxpresso_1769.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/keil_output/chip_175x_6x_lib/: chip_175x_6x_lib.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/usbd_lib/keil/: usbd_175x_6x_lib.lib
