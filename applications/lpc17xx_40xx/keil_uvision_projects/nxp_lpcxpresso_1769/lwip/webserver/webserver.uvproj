# Keil uVision project webserver.uvproj, settings and files
target iflash_nxp_lpcxpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lwip_webserver_iflash_nxp_lpcxpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\tcpecho_raw;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\examples\lwip\webserver\configs
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../../../software/lwip/contrib/apps/tcpecho_raw/: echo.c
    ../../../../examples/lwip/webserver/: webserver.c httpd.c lwip_fs.c readme.txt
    ../../../../startup_code/: sysinit.c
    ../../../../examples/lwip/startup_code/: keil_startup_lpc17xx_40xx.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/keil_output/: board_nxp_lpcxpresso_1769.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/keil_output/chip_175x_6x_lib/: chip_175x_6x_lib.lib
  group LWIP
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: ip_frag.c ip_addr.c ip.c inet_chksum.c inet.c igmp.c icmp.c autoip.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c
  group lpclwip
    ../../../../../../software/lwip/lpclwip/arch/: lpc_debug.c lpc17xx_40xx_systick_arch.c lpc17xx_40xx_emac.c
