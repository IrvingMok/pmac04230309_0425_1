# Keil uVision project lwip_tcpecho_freertos.uvproj, settings and files
target iflash_nxp_lpcxpresso_1769 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lwip_tcpecho_freertos_iflash_nxp_lpcxpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\examples\lwip\lwip_tcpecho_freertos\configs
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../../../software/lwip/contrib/apps/tcpecho/: tcpecho.c
    ../../../../examples/lwip/lwip_tcpecho_freertos/: lwip_tcpecho_freertos.c readme.txt
    ../../../../startup_code/: sysinit.c
    ../../../../examples/lwip/startup_code/: keil_startup_lpc17xx_40xx.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/keil_output/: board_nxp_lpcxpresso_1769.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/keil_output/chip_175x_6x_lib/: chip_175x_6x_lib.lib
  group FreeRTOS_17xx
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/: croutine.c queue.c list.c tasks.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group LWIP
    ../../../../../../software/lwip/lwip/src/core/: udp.c timers.c tcp_out.c tcp_in.c tcp.c sys.c stats.c raw.c pbuf.c netif.c memp.c mem.c init.c dns.c dhcp.c def.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: ip_frag.c ip_addr.c ip.c inet_chksum.c inet.c igmp.c icmp.c autoip.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c
    ../../../../../../software/lwip/lwip/src/api/: tcpip.c sockets.c netifapi.c api_msg.c api_lib.c netdb.c err.c
  group lpclwip
    ../../../../../../software/lwip/lpclwip/arch/: sys_arch_freertos.c lpc_debug.c lpc17xx_40xx_systick_arch.c lpc17xx_40xx_emac.c
    ../../../../../../software/lwip/lwip/src/api/: netbuf.c
