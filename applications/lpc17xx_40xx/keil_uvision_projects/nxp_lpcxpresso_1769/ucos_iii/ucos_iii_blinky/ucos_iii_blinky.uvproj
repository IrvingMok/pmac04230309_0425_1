# Keil uVision project ucos_iii_blinky.uvproj, settings and files
target iflash_nxp_lpcxpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ucos_iii_blinky_iflash_nxp_lpcxpresso_1769
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core;..\..\..\..\..\..\software\CMSIS;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769;..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Source;..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU;..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\..\software\ucos_iii\Micrium\Software\uC-LIB;..\..\..\..\examples\ucos_iii\ucos_iii_blinky\ucos_iii_config;..\..\..\..\examples\ucos_iii\ucos_iii_blinky\
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx_40xx\nxp_lpcxpresso_1769
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../examples/ucos_iii/ucos_iii_blinky/: ucos_iii_blinky.c
    ../../../../examples/ucos_iii/startup_code/: keil_ucos_iii_startup_lpc17xx_40xx.s
    ../../../../startup_code/: sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/keil_output/: board_nxp_lpcxpresso_1769.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/keil_output/chip_175x_6x_lib/: chip_175x_6x_lib.lib
    ../../../../examples/ucos_iii/ucos_iii_blinky/: readme.txt
  group ucos_iii_17xx
    ../../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
    ../../../../../../software/ucos_iii/Micrium/Software/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm
  group ucos_iii
    ../../../../../../software/ucos_iii/Micrium/Software/uCOS-III/Source/: os_var.c os_tmr.c os_time.c os_tick.c os_task.c os_stat.c os_sem.c os_q.c os_prio.c os_pend_multi.c os_mutex.c os_msg.c os_mem.c os_int.c os_flag.c os_dbg.c os_core.c os_cfg_app.c
    ../../../../../../software/ucos_iii/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../../../../software/ucos_iii/lpc_ucos_iii/lpc17xx40xx_bsp/: cpu_bsp.c
