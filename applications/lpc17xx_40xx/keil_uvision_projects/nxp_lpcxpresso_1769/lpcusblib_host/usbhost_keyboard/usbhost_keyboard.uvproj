# Keil uVision project usbhost_keyboard.uvproj, settings and files
target iflash_nxp_lpcxpresso_1769 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbhost_keyboard
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3 __LPC175X_6X__ USB_HOST_ONLY
  c misc: --gnu --c99
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_17xx\nxp_lpcxpresso_1769;..\..\..\..\..\..\software\LPCUSBLib\Drivers\USB
  asm define: CORE_M3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group example
    ../../../../startup_code/: keil_startup_lpc175x_6x.s sysinit.c
    ../../../../examples/LPCUSBlib/lpcusblib_KeyboardHost/: KeyboardHost.c
  group lpcusblib
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/: Host.c HostStandardReq.c USBTask.c ConfigDescriptor.c USBMemory.c USBController.c Pipe.c PipeStream.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Class/Host/: HIDClassHost.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Class/Common/: HIDParser.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/OHCI/: OHCI.c
    ../../../../examples/LPCUSBlib/lpcusblib_KeyboardHost/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_17xx_40xx/keil_output/chip_175x_6x_lib/: chip_175x_6x_lib.lib
    ../../../../../../software/lpc_core/lpc_board/boards_17xx/nxp_lpcxpresso_1769/keil_output/: board_nxp_lpcxpresso_1769.lib
