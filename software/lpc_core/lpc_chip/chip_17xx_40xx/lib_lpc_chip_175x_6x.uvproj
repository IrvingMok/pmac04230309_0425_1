# Keil uVision project lib_lpc_chip_175x_6x.uvproj, settings and files
target chip_175x_6x_lib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: chip_175x_6x_lib (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\software\lpc_core\lpc_chip\chip_17xx_40xx;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS;.\config_175x_6x
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group csp
    ./: adc_17xx_40xx.c can_17xx_40xx.c clock_17xx_40xx.c dac_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c sysctl_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c wwdt_17xx_40xx.c pmu_17xx_40xx.c stopwatch_17xx_40xx.c chip_17xx_40xx.c sysinit_17xx_40xx.c gpioint_17xx_40xx.c
    ../../lpc_chip/chip_common/: ring_buffer.c
    ../chip_common/: iap.c
