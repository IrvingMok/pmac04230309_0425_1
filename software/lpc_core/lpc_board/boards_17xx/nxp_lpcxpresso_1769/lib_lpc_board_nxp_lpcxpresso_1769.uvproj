# Keil uVision project lib_lpc_board_nxp_lpcxpresso_1769.uvproj, settings and files
target nxp_lpcxpresso_1769 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: board_nxp_lpcxpresso_1769 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: .\;..\..\..;..\..\..\lpc_chip\chip_17xx_40xx;..\..\..\lpc_chip\chip_17xx_40xx\config_175x_6x;..\..\board_common;..\..\..\lpc_chip\chip_common;..\..\..\..\CMSIS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group board_nxp_lpcxpresso_1769
    ../../board_common/: lpc_phy_smsc87x0.c
    ./: board.c board_sysinit.c
